# Keil uVision project stm32f407.uvprojx, settings and files
target stm32f407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\app;..\app\ui;..\app\font;..\app\image;..\devices;..\driver;..\system;..\firmware\driver\inc;..\firmware\cmsis\device;..\firmware\cmsis\core;..\third_lib\freertos\include;..\third_lib\freertos\portable
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c board.c wireless.c wireless.h app.c app.h workqueue.c workqueue.h
  group app/ui
    ../app/ui/: ui.c ui.h welcome_page.c error_page.c wifi_page.c main_page.c page.h
  group app/font
    ../app/font/: font16_ascii.c font20.c font24.c font32.c font54_temper.c font54_humidity.c font76_time.c font.h
  group app/image
    ../app/image/: ima_welcome.c ima_error.c ima_wifi.c icon_duoyun.c icon_leizhenyu.c icon_na.c icon_qing.c icon_wenduji.c icon_xue.c icon_yintian.c icon_yueliang.c icon_zhongyu.c icon_wifi.c image.h
  group devices
    ../devices/: espat.c espat.h weather.c weather.h
  group driver
    ../driver/: serial.c serial.h lcd.c lcd.h rtc.c rtc.h aht20.c aht20.h
  group system
    ../system/: delay.c delay.h
  group firmware/cmsis
    ../firmware/cmsis/device/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group third_lib
    ../third_lib/freertos/: tasks.c queue.c list.c timers.c
    ../third_lib/freertos/portable/: port.c heap_4.c FreeRTOSConfig.h
